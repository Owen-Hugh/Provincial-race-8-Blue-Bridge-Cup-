# Keil uVision project 1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\code
  group Source Group 1
    ./: main.c time.c
    ./code/: bsp_init.c smg_init.c ds1302.c
